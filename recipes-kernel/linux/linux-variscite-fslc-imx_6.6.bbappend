FILESEXTRAPATHS:prepend := "${THISDIR}/files/6.6/:"

require recipes-kernel/linux/morse-kernel-6.6.inc
