FILESEXTRAPATHS:prepend := "${THISDIR}/files/5.15/:"

SRC_URI += "file://0001-arm-dts-replace-broadcom-node-with-morse.-Disable-SD.patch"
SRC_URI += "file://0001-mac80211-diable-robust-management-frame-without-sta-.patch"
SRC_URI += "file://0002-sdhci-esdhc-imx-reorder-clock-gating-on-suspend.patch"
SRC_URI += "file://0002-mac80211-mlme-s1g-ecsa-support.patch"
SRC_URI += "file://0003-mac80211-tx-s1g-AP-ecsa-support.patch"
SRC_URI += "file://0004-mac80211-IBSS-bridge-support.patch"
SRC_URI += "file://0005-mac80211-mesh-support.patch"
SRC_URI += "file://0006-sdio-1.8v-quirk.patch"
SRC_URI += "file://0007-mac80211-ndp-block-ack.patch"
